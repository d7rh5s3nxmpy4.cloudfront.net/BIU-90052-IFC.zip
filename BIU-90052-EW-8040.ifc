Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-10-21T11:11:37
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: BILLUND 2 Street and area lighting luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - Colour 3000K and 4000K - Die-cast aluminium housing - Pre-treated before powder coating ensuring high corrosion resistance - Thermal heat dissipation body - Single cable entry - One IP68 connector supplied with 0.3 m of 3x1.0 sqmm outdoor cable - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - Clear toughened glass - High-efficiency polycarbonate lens - Integral control gear - Surge protection 10kV - Constant lumen output (CLO) and Night-time dimming options; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: BILLUND, Street and area lighting luminaires; Housing color: Not specified
General Information - Article number: BIU-90052-EW-8040; Article name: BILLUND 2 Street and area lighting luminaires; Weight: 10.3 kg; Case length: 76.5 cm; Case width: 38.1 cm; Case height: 11.8 cm; Uld creation date: 21.10.2024 09:11:37
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 113 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 113 W; LightFixtureMountingType: PoleIntegrated; ManufacturersSpecificInformation: LIGMAN

# IfcFlowTerminal: BIU-90052-EW-8040
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: BIU-90052-EW-8040; Light output ratio: 1; Luminous flux: 13605.3 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 13605.3 lm; LightEmitterNominalPower: 113 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorTemperature: 4000 K; ColorRenderingIndex: 80
